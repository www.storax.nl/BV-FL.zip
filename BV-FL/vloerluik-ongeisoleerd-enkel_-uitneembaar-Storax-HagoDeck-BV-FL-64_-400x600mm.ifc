Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: f6cdc44e-de88-4204-99bd-e933ffb20148.ifc
Time: 2026-09-11T16:22:23
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck BV-FL 64, 400x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAIR3dbYDAAAAccMAAAV2SgAA2FMBAFJfAQDxgwAAQQEAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAIR3dbYDAAAAccMAAAV2SgAA2FMBAFJfAQDxgwAAQQEAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 17 kg/st; STABU2: 43.31.10; dagmaatlengte: 400 mm; lengte: 530 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 730 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 50 mm; merk: Storax; breuklast: A15; type: BV-FL 64; dagmaatbreedte: 600 mm; omranding: staal; luik: staal
