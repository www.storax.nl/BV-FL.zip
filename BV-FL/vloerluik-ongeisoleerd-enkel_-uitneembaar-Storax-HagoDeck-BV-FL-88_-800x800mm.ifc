Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: f9f19e47-89a5-40bb-b99c-70d77bf626e7.ifc
Time: 2026-09-11T16:24:18
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck BV-FL 88, 800x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAIS5o7YDAAAAccMAAAV2SgAA2FMBAFJfAQDxgwAAj9cAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAIS5o7YDAAAAccMAAAV2SgAA2FMBAFJfAQDxgwAAj9cAAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 31 kg/st; STABU2: 43.31.10; dagmaatlengte: 800 mm; lengte: 930 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 930 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 50 mm; merk: Storax; breuklast: A15; type: BV-FL 88; dagmaatbreedte: 800 mm; omranding: staal; luik: staal
